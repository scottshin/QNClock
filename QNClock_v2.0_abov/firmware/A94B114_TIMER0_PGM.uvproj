# Keil uVision project A94B114_TIMER0_PGM.uvproj, settings and files
target Target 1 (MCS-51)
  device: A94B114 ABOV Semiconductor
  cpu: IRAM(0x00 - 0xFF) XRAM(0x0000-0x1FFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: A94B114_TIMER0_PGM +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Main.c Clock.c Timer.c I2C.c a94b114_flash.c
